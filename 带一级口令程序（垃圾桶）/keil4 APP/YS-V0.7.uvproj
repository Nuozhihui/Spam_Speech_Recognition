# Keil uVision project YS-V0.7.uvproj, settings and files
target YS-V0.7口令模式工程 08xe (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: V07A +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c LDChip.c Reg_RW.c
  group Driver
    ../user/: usart.c
